require astra-media-swupdate-fix.inc
