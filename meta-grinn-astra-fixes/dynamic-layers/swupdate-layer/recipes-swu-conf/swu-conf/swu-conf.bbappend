do_install:append() {
	rm -r ${D}${sysconfdir}/www/
}
