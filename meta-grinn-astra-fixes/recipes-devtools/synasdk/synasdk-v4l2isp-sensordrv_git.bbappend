FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-OV5647-disable-horizontal-mirror.patch \
"
