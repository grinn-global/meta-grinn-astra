require astra-media-extensions.inc
require recipes-bsp/images/astra-media-swupdate-fix.inc
