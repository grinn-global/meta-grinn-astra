FW_ENV_CONFIG = "fw_env_sl1680.config"
